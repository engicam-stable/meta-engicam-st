CORE_IMAGE_EXTRA_INSTALL += " \
    brcm-patchram-plus \
    can-utils \
    devmem2 \
    eng-emmc-tools \
    iperf3 \
    libsocketcan  \
    minicom \
    mtd-utils-ubifs \
    u-boot-stm32mp-splash \
    "


