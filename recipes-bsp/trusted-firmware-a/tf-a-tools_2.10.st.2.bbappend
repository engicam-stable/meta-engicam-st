FILESEXTRAPATHS:prepend:stm32mp15-icore := "${THISDIR}/${PN}:"

